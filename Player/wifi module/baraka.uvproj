# Keil uVision project baraka.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: baraka
  c flags: Optim=1
  c include: .\common_files;.\ECUAL\Button;.\ECUAL\LCD;.\ECUAL\RGB_LED;.\MCAL\DIO;.\MCAL\UART;.\ECUAL\mp3;.\ECUAL\esp8266
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c
    ./ECUAL/Button/: button.c pushbutton.c
    ./ECUAL/LCD/: LCD_clearScreen.c LCD_displayCharacter.c LCD_displayString.c LCD_displayStringRowColumn.c LCD_goToRowColumn.c LCD_init.c LCD_intgerToString.c LCD_sendCommand.c
    ./ECUAL/RGB_LED/: RGB_LED.c
    ./MCAL/DIO/: DIO.c DIO_EnableExtInt.c DIO_init.c
    ./MCAL/UART/: UART_Available.c UART_Init.c Uart_Print.c UART_Read.c UART_Write.c
    ./common_files/: SysTick.c PLL.c
    ./ECUAL/mp3/: Mp3.c
    ./ECUAL/esp8266/: esp8266.c
